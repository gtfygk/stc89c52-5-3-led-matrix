# Repository gtfygk/stc89c52-5-3-led-matrix

File README.md:

# STC89C52RC 5×3 LED 点阵倒计时项目（大一 Frozen 项目）

**项目状态：Frozen（已冻结）（2026.3）**

大一时从零完成的练习项目：用 STC89C52RC 驱动 5×3 共阳 LED 点阵，实现数字倒计时（9→0）。  
目前卡在**单片机 ISP 下载无法识别**阶段，因此先冻结，留待未来的我去完成。  

---

## 项目简介
- **MCU**：STC89C52RC（8051 内核）
- **LED 点阵**：5 列 × 3 行（共阳极，手工焊接）
- **扫描方式**：行列动态扫描 + 倒计时显示
- **开发板**：万能板（perfboard）手工焊接
- **软件**：**SDCC + VS Code**（模块化 src/inc 结构，非 Keil C51）

## 文件结构
- **stc89c52-5-3-led-matrix/**
- **├── .gitignore**
- **├── README.md**
- **├── Photos/                          # 实物焊接照片（正面、背面等）**
- **├── STC89C52RC_Project/**
- **│   ├── Firmware/                    # 固件源码与编译文件（SDCC 生成）**
- **│   │   ├── countdown.ihx            # 可直接烧录的固件文件**
- **│   │   ├── inc/                     # 头文件**
- **│   │   │   ├── delay.h**
- **│   │   │   └── led_matrix.h**
- **│   │   └── src/                     # 源代码**
- **│   │       ├── delay.c**
- **│   │       ├── led_matrix.c**
- **│   │       └── main.c**
- **│   └── kicad_file/**
- **│       └── stc89c52rc_led_5×3_matrix_perfboard/   # KiCAD 项目文件夹**
- **│           ├── BOM.csv              # 物料清单**
- **│           ├── stc89c52rc_led_5×3_matrix_perfboard.kicad_sch**
  **│           ├── stc89c52rc_led_5×3_matrix_perfboard.kicad_pcb**
- **│           ├── stc89c52rc_led_5×3_matrix_perfboard.kicad_pro**
- **│           └── gerber/              # Gerber 生产文件**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-F_Cu.gtl**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-B_Cu.gbl**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-F_Mask.gts**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-B_Mask.gbs**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-F_Silkscreen.gto**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-B_Silkscreen.gbo**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-Edge_Cuts.gm1**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-NPTH.drl**
- **│               ├── stc89c52rc_led_5×3_matrix_perfboard-PTH.drl**
- **│               └── stc89c52rc_led_5×3_matrix_perfboard-job.gbrjob**

## 当前卡住的问题
STC-ISP 始终无法识别单片机。  

## 未来想法
当我有了一些经验和自信之后，我就会重新捡起我这个frozen项目，我也许也会做出一些改进。

## KiCad design STC89C52RC_Project/kicad_file/stc89c52rc_led_5×3_matrix_perfboard/stc89c52rc_led_5×3_matrix_perfboard.kicad_pcb

Parts:
C1, C2, C5: 0.1uf; CP_Radial_D5.0mm_P2.50mm
C3, C4: 10uf; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15: LED; LED_D5.0mm
R1, R2, R3: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 10kR; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SW_Push; SW_PUSH_6mm_H5mm
U1: STC89C52RC; DIP-40_W25.4mm
Y1: 11.0592MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C1.1, C3.2, R4.2, U1.31 (~EA/V_{pp}), U1.40 (V_{cc})
GND: C1.2, C2.2, C3.1, C4.2, C5.2, SW1.1, U1.20 (GND)
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), R1.2
unnamed: D1.1 (K), D10.1 (K), D11.1 (K), U1.35 (P0.4/AD4)
unnamed: D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), R2.2
unnamed: D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), R3.2
unnamed: D2.1 (K), D9.1 (K), D12.1 (K), U1.36 (P0.3/AD3)
unnamed: D3.1 (K), D8.1 (K), D13.1 (K), U1.37 (P0.2/AD2)
unnamed: D4.1 (K), D7.1 (K), D14.1 (K), U1.38 (P0.1/AD1)
unnamed: D5.1 (K), D6.1 (K), D15.1 (K), U1.39 (P0.0/AD0)
unnamed: R1.1, U1.1 (P1.0)
unnamed: R2.1, U1.3 (P1.2)
unnamed: R3.1, U1.5 (P1.4)
unnamed: C4.1, R4.1, SW1.2, U1.9 (RST)
unnamed: C2.1, U1.19 (XTAL1), Y1.2
unnamed: C5.1, U1.18 (XTAL2), Y1.1

Notes on the sheet:
Col.1> p1.0 Col.2> p1.2 Col.3> p1.4
Row1> p0.0 Row2> p0.1 Row3> p0.2 Row4> p0.3 Row5> p0.4
列共阳极连接220R电阻 行共阴极
LED 5×3 matrix

Board: 2 copper layers, 80.0 x 120.0 mm, 27 parts (0 on the bottom side), 16 nets.

## Commit log

2026-02-14 Revise README for STC89C52 LED Matrix Display
    Updated project title and added overview and hardware details.
2026-02-17 Format hardware list in README.md
2026-03-03 Rename stc89c52rc_led_5×3_matrix_perfboard.csv to BOM.csv
2026-03-03 Rename IMG_20260303_152850.jpg to first,up
2026-03-03 Rename IMG_20260303_152850.jpg to Photo 1 front.jpg
    Rename for a more suitable name
2026-03-03 Delete Photos/Photo 1 front.jpg
    i don't know how to rename
2026-03-03 Enhance .gitignore with more file exclusions
    Updated .gitignore to include additional temporary files and build artifacts.
2026-03-03 Revise file structure in README.md
    Updated the file structure section to include detailed directory information for the project.
2026-03-03 Fix formatting in README.md file structure section
